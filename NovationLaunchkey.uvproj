# Keil uVision project NovationLaunchkey.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC120RC1AN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x07FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NovationLaunchkey
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c include: .\lib\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;.\lib\CMSIS\CM0\CoreSupport;.\src\Hardware;.\lib\NuvotonPlatform_Keil\Include;.\lib\NuvotonPlatform_Keil\Include\Driver;.\src\Application;.\src\HAL;.\src\Util
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Source
    ./src/: main.c
  group Hardware
    ./src/Hardware/: HardwareSpecific.c LED.c MultiplexControl.c Timer.c UART.c ADC.c LED_7Seg.c FSR.c Switch.c Keyboard.c USB_Audio.c USB_Descriptors.c USBMIDI.c
  group CMSIS
    ./lib/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ./lib/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
    ./lib/CMSIS/CM0/CoreSupport/: core_cm0.c
  group NuvotonBSP
    ./lib/NuvotonPlatform_Keil/Src/Driver/: DrvGPIO.c DrvSYS.c DrvADC.c DrvTIMER.c DrvUART.c DrvUSB.c
  group Application
    ./src/Application/: softtimer.c TimerCallbacks.c App_Keyboard.c App_MIDI.c App_Switch.c ModeManager.c Mode_OctaveTranspose.c Mode_Global.c InputManager.c App_GlobalSettings.c Global_ADC.c ADC_CentreDetent.c Mode_Remap.c ControlSurfaceMap.c App_Data.c Mode_Controller.c
  group HAL
    ./src/HAL/: HAL_KB.c EventManager.c DisplayManager.c KeyboardEvents.c HAL_MIDI.c SwitchEvents.c ADCEvents.c GenericEvents.c
  group Util
    ./src/Util/: binarySearch.c voidbuffer.c uint16toa.c Rescale.c
