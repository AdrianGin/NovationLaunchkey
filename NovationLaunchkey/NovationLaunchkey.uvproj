# Keil uVision project NovationLaunchkey.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC120RC1AN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x07FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NovationLaunchkey
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1
  c include: .\lib\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;.\lib\CMSIS\CM0\CoreSupport;.\src\Hardware;.\lib\NuvotonPlatform_Keil\Include;.\lib\NuvotonPlatform_Keil\Include\Driver;.\src\Application;.\src\HAL;.\src\Util
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Source
    ./src/: main.c
  group Hardware
    ./src/Hardware/: HardwareSpecific.c LED.c MultiplexControl.c Timer.c UART.c ADC.c LED_7Seg.c FSR.c Switch.c Keyboard.c
  group CMSIS
    ./lib/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ./lib/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
    ./lib/CMSIS/CM0/CoreSupport/: core_cm0.c
  group NuvotonBSP
    ./lib/NuvotonPlatform_Keil/Src/Driver/: DrvGPIO.c DrvSYS.c DrvADC.c DrvTIMER.c DrvUART.c
  group Application
    ./src/Application/: softtimer.c TimerCallbacks.c
  group HAL
    ./src/HAL/: HAL_KB.c
  group Util
    ./src/Util/: binarySearch.c
